Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2015-08-13T11:52:35
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130709_2115(x64) - Exporter 3.13.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Aug 13 11:52:35 2015* Host: NCL-TA28* Database: C:\Users\hibbertj\AppData\Local\Temp\{F57542EE-8A6D-4F16-8F4B-8D4719C8E117}\ifc* Database version: 5507* Database creation date: Thu Aug 13 11:52:30 2015* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Aug 13 11:52:31 2015* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Aug 13 11:52:31 2015* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: NBS_PineappleContracts_DomesticChairs_RynoLoungeChair, NBS_PineappleContracts_DmstcChrs_RynoLoungeChair:NBS_PineappleContracts_DomesticChairs_RynoLoungeChair:218020
In: Level 0
Type - Classification: Pr_40_50_12_22 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_PineappleContracts_DomesticChairs_RynoLoungeChair; ManufacturerName: Pineapple Contracts; ManufacturerURL: www.pineapplecontracts.com; NBSCertification: www.nationalbimlibrary.com/cert/odpawozy; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: www.pineapplecontracts.com/userfiles/file/RYNO-brochure.pdf; Revision: n/a; Version: 6; Uniclass2015Title: Dining chairs; Uniclass2015Code: Pr_40_50_12_22; Uniclass2015Version: Products v1.13
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: Pr_40_50_12_22:Dining chairs; CodePerformance: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Difficult to pick up due to flowing, contoured design, rounded top to prevent sitting on the back of the chair, ergonomically designed to give excellent comfort; Finish: Anti-microbial, wipe-clean surface with excellent chemical resistance; Grade: n/a; Manufacturer: www.pineapplecontracts.com; Material: Polyethylene; ModelNumber: ARD-000; ModelReference: Ryno Lounge Chair; Name: DomesticChairs_RynoLoungeChair_PineappleContracts; NominalWidth: 500 mm; ReplacementCost: n/a; Shape: n/a; Size: 780 x 600 x 760 mm; SustainabilityPerformance: n/a; WarrantyDescription: Guarantee against manufacturing faults; WarrantyDurationLabor: n/a; WarrantyDurationParts: 7; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_FurnitureTypeCommon - Description: Polyethylene dining chair; IsBuiltIn: no; MainColor: n/a; NominalDepth: 760 mm; NominalHeight: 780 mm; NominalLength: 0 mm
Type - Pset_FurnitureTypeChair - HighestSeatingHeight: 0 mm; LowestSeatingHeight: 0 mm; SeatingHeight: 420 mm
Type - NBS_Data - Accessories: Connecting plate; ColourOptions: blaze orange, vegas yellow, icon purple, epic blue, moonwalk grey, thunder grey, cool green, lime green, black, granite; EnvironmentalProductDeclaration: n/a; ExposedEdges: Rounded; FabricLocationOptions: None (RYND), Upholstered back (RYNDB), Upholstered seat (RYNDS), Upholstered back and seat (RYNDSB); FabricOptions: A wide choice of fabrics are available; Feet: Stainless steel glides; StrengthAndStability: Level 2; Weight: 75 kg
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
